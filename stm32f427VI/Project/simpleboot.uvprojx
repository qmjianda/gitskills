# Keil uVision project simpleboot.uvprojx, settings and files
target Code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloder +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CORE;..\Libraries\inc;..\User\port;..\User\ymodem;..\User
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libraries/CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../User/: boot_config.h
    ../Libraries/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group CMSIS
    ../User/: system_stm32f4xx.c
  group Port
    ../User/port/: bsp_ring.c delay.c flash.c uart.c
  group User
    ../USER/: main.c stm32f4xx_it.c
    ../User/: bootloder.c bootloder.h
    ../User/ymodem/: ymodem.c ymodem_port.c
